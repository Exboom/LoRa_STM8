# IAR project remote.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Work\Projects\remote\libraries\inc; C:\Work\Projects\remote\libraries\lora
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: C:\Work\Projects\remote\libraries\inc; C:\Work\Projects\remote\libraries\src; C:\Work\Projects\remote\libraries\lora
  OBJCOPY.OOCOutputFile: remote.srec
  ILINK.IlinkOutputFile: remote.out
  group (top)
    ./: main.c
  group inc
    libraries/inc/: delay.h stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_conf.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_gpio.h stm8l15x_it.h stm8l15x_itc.h stm8l15x_spi.h
  group lora
    libraries/lora/: lora.c lora.h
  group src
    libraries/src/: delay.c stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_it.c stm8l15x_itc.c stm8l15x_spi.c
